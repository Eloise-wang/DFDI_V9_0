# IAR project Bldc_App.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AC78406HGLA AutoChips AC78406HGLA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\CMSIS\Device; ..\CMSIS\Device\ac7840x\include; ..\CMSIS\Device\ac7840x\startup; ..\CMSIS\Device\ac7840x\startup\armc; ..\CMSIS\Device\common; ..\CMSIS\Driver\inc; ..\CMSIS\Driver\src\acmp; ..\CMSIS\Driver\src\adc; ..\CMSIS\Driver\src\ckgen; ..\CMSIS\Driver\src\ctu; ..\CMSIS\Driver\src\dma; ..\CMSIS\Driver\src\flash; ..\CMSIS\Driver\src\gpio; ..\CMSIS\Driver\src\pdt; ..\CMSIS\Driver\src\pwm; ..\CMSIS\Driver\src\rcm; ..\CMSIS\Driver\src\spi; ..\CMSIS\Driver\src\spm; ..\CMSIS\Driver\src\timer; ..\CMSIS\Driver\src\uart; ..\CMSIS\Driver\src\wdg; ..\CMSIS\Rtos\osif; ..\Inc\Common_Cfg; ..\Inc\Bldc_Cfg; ..\Motor-Master\Bldc\Bldc_App\inc; ..\Motor-Master\User\Bldc\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Motor_App.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Application/User
    ../Src/Bldc/: main.c
  group Mcu/Device
    ../CMSIS/Device/ac7840x/startup/: debugout_ac7840x.c system_ac7840x.c
    ../CMSIS/Device/ac7840x/startup/armc/: startup_ac7840x.s
  group Mcu/Driver
    ../CMSIS/Driver/src/acmp/: acmp_drv.c acmp_hw.c acmp_irq.c
    ../CMSIS/Driver/src/adc/: adc_drv.c adc_hw.c adc_irq.c
    ../CMSIS/Driver/src/ckgen/: ckgen_drv.c ckgen_hw.c
    ../CMSIS/Driver/src/ctu/: ctu_drv.c ctu_hw.c
    ../CMSIS/Driver/src/dma/: dma_drv.c dma_hw.c dma_irq.c
    ../CMSIS/Driver/src/flash/: flash_drv.c flash_irq.c
    ../CMSIS/Driver/src/gpio/: gpio_drv.c gpio_irq.c port_hw.c
    ../CMSIS/Rtos/osif/: osif_baremetal.c
    ../CMSIS/Driver/src/pdt/: pdt_drv.c pdt_hw.c pdt_irq.c
    ../CMSIS/Driver/src/pwm/: pwm_common.c pwm_hw.c pwm_input.c pwm_irq.c pwm_output.c
    ../CMSIS/Driver/src/rcm/: rcm_drv.c
    ../CMSIS/Driver/src/spi/: spi_hw.c spi_irq.c spi_master_drv.c spi_shared_function.c spi_slave_drv.c
    ../CMSIS/Driver/src/spm/: spm_drv.c spm_irq.c
    ../CMSIS/Driver/src/timer/: timer_drv.c timer_irq.c
    ../CMSIS/Driver/src/uart/: uart_drv.c uart_hw.c uart_irq.c
    ../CMSIS/Driver/src/wdg/: wdg_drv.c wdg_hw.c wdg_irq.c
  group Motor/Bldc_App
    ../Motor-Master/Bldc/Bldc_App/src/: bldc_adc.c bldc_app.c bldc_bemf.c bldc_common.c bldc_control_api.c bldc_isr.c bldc_parameters_init.c bldc_pid.c bldc_protector.c bldc_pwm.c bldc_speed.c bldc_startup.c
  group Motor/Cfg
    ../Inc/Bldc_Cfg/: bldc_parameters_define.h
    ../Inc/Common_Cfg/: hwboard_parameters_define.h motor_parameters_define.h
  group Motor/User
    ../Motor-Master/User/Bldc/src/: bldc_data_access_eflash.c bldc_keys.c bldc_mcu_config.c bldc_ui_uart.c clock_config.c task_scheduler.c
